# Keil uVision project fingerprint.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: fingerprint +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Include;E:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: main.c
    ./Source/: oled.c ds1302.c fp_diver.c uart.c
